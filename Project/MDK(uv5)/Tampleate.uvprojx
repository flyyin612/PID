# Keil uVision project Tampleate.uvprojx, settings and files
target Tampleate (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Tampleate
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\HardWare\led;..\..\HardWare\key;..\..\HardWare\timer;..\..\HardWare\nvic;..\..\HardWare\motor;..\..\User\system;..\..\HardWare\oled;..\..\Application;..\..\HardWare\encoder;..\..\HardWare\usart1;..\..\HardWare\wave
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/system/: sys.c
  group HardWare
    ../../HardWare/led/: led.c
    ../../HardWare/key/: key.c
    ../../HardWare/timer/: timer.c
    ../../HardWare/nvic/: nvic.c
    ../../HardWare/motor/: motor.c
    ../../HardWare/oled/: oled.c show.c
    ../../HardWare/encoder/: encoder.c
    ../../HardWare/usart1/: usart.c
    ../../HardWare/wave/: wave.c
  group Application
    ../../Application/: work.c
